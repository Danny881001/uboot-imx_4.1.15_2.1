## board/freescale/mx6peach/Kconfig
```kconfig
if TARGET_MX6PEACH

config SYS_BOARD
	default "mx6peach"

config SYS_VENDOR
	default "freescale"

config SYS_CONFIG_NAME
	default "mx6peach"

endif
```
